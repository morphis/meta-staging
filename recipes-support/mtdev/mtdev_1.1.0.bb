DESCRIPTION = "Multitouch Protocol Translation Library"
HOMEPAGE = ""
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING;md5=ea6bd0268bb0fcd6b27698616ceee5d6"
PR = "r0"

SRC_URI = "http://bitmath.org/code/mtdev/mtdev-1.1.0.tar.bz2"
SRC_URI[md5sum] = "d5fd97b5bd6ab093d4ddb16a83e8ead2"
SRC_URI[sha256sum] = "4cdd9f72ea04536788ddf2ddef7279abb44b7b4a466e6bd01bdd975cf236aa50"

inherit autotools
